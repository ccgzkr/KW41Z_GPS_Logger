# Keil uVision project gps.uvprojx, settings and files
target gps (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKW41Z512xxx4 NXP
  pack: Keil.Kinetis_KWxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x00080000) IRAM(0x1FFF8000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gps
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKW41Z512VHT4, FRDM_KW41Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: CMSIS;board;doc;drivers;source;startup;utilities
  asm define: DEBUG
  asm include: CMSIS;board;doc;drivers;source;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x20000
  scatter file: MKW41Z512xxx4_flash.scf
  link misc: --remove
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h RTE_Device.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0plus.h core_cmFunc.h core_cmInstr.h core_cmSimd.h fsl_device_registers.h MKW41Z4.h MKW41Z4_features.h system_MKW41Z4.c system_MKW41Z4.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: Driver_CAN.h Driver_Common.h Driver_ETH.h Driver_ETH_MAC.h Driver_ETH_PHY.h Driver_Flash.h Driver_I2C.h Driver_MCI.h Driver_NAND.h Driver_SAI.h Driver_SPI.h Driver_USART.h Driver_USB.h Driver_USBD.h Driver_USBH.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_cmsis.c fsl_lpuart_cmsis.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_port.h fsl_smc.c fsl_smc.h
    ./drivers/: fsl_tpm.c fsl_tpm.h
  group source
    ./source/: swu.c
  group startup
    startup/: startup_MKW41Z4.s
  group utilities
    utilities/: fsl_debug_console.c fsl_debug_console.h
